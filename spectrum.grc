options:
  parameters:
    author: m6r3k
    generate_options: qt_gui
    id: spectrum
    output_language: python
    realtime_scheduling: '1'
    title: Spectrum
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    min_len: '120'
    start: '100000'
    step: '100000'
    stop: '30000000'
    value: '30000000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: '50000000'
    step: '1000000'
    stop: '3000000000'
    value: '2400000000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: BW
    fc: center_freq
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    rate: '1000'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '0'
    center_freq: center_freq
    gain: '35.0'
    maxoutbuf: '8192'
    minoutbuf: '4096'
    samp_rate: BW
    type: fc32
  states: {}

connections:
- [soapy_limesdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
